# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\key;.\APP\exti;.\APP\time;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\rng;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\flash;.\APP\spi;.\APP\stm32_flash;.\APP\sram;.\Malloc;.\APP\sd;.\Fatfs\src;.\Fatfs\fatfs_app;.\Font;.\Picture;.\APP\pwm;.\APP\rs232;.\LwIP;.\LwIP\arch;.\LwIP\lwip_app\lwip_comm;.\LwIP\lwip-1.4.1\src\include;.\LwIP\lwip-1.4.1\src\include\ipv4;.\LwIP\lwip-1.4.1\src\include\netif;.\Libraries\STM32F4x7_ETH_Driver\inc;.\APP\lan8720;.\USB\USB_APP;.\USB\STM32_USB_OTG_Driver\inc;.\USB\STM32_USB_HOST_Library\Core\inc;.\USB\STM32_USB_HOST_Library\Class\MSC\inc;.\APP\touch_key;.\APP\lsens;.\APP\mpu6050;.\APP\mpu6050\eMPL;.\APP\touch;.\T9INPUT;.\ICON;.\GUI;.\GUI_APP;.\APP\wm8978;.\APP\nrf24l01;.\APP\i2s;.\AudioDecod;.\AudioDecod\wav;.\USB\STM32_USB_Device_Library\Core\inc;.\USB\STM32_USB_Device_Library\Class\msc\inc;.\LwIP\lwip_app\web_server_demo;.\APP\dcmi;.\APP\ov2640;.\MJPEG;.\MJPEG\JPEG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_rng.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_can.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_sdio.c stm32f4xx_dcmi.c
    ./Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group APP
    ./APP/led/: led.c
    ./APP/key/: key.c
    ./APP/sram/: sram.c
    ./APP/beep/: beep.c
    ./APP/24Cxx/: 24cxx.c
    ./APP/iic/: iic.c
    ./APP/flash/: flash.c
    ./APP/spi/: spi.c
    ./APP/time/: time.c
    ./APP/rtc/: rtc.c
    ./APP/sd/: sdio_sdcard.c
    ./APP/hwjs/: hwjs.c
    ./APP/rs232/: rs232.c
    ./APP/lan8720/: lan8720.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/touch/: ctiic.c gt5663.c touch.c cst716.c
    ./APP/adc/: adc.c
    ./APP/adc_temp/: adc_temp.c
    ./APP/ds18b20/: ds18b20.c
    ./APP/can/: can.c
    ./APP/rs485/: rs485.c
    ./APP/touch_key/: touch_key.c
    ./APP/lsens/: lsens.c
    ./APP/mpu6050/: mpu6050.c
    ./APP/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./APP/wm8978/: wm8978.c
    ./APP/nrf24l01/: nrf24l01.c
    ./APP/i2s/: i2s.c
    ./APP/dcmi/: dcmi.c
    ./APP/ov2640/: ov2640.c sccb.c
  group Malloc
    ./Malloc/: malloc.c
  group Fatfs
    ./Fatfs/src/: diskio.c ff.c
    ./Fatfs/fatfs_app/: fatfs_app.c mycc936.c
  group Font
    ./Font/: font_show.c font_update.c
  group Picture
    ./Picture/: bmp.c gif.c piclib.c tjpgd.c
  group T9INPUT
    ./T9INPUT/: pyinput.c t9input.c
  group AudioDecode
    ./AudioDecod/: audioplay.c videoplayer.c
    ./AudioDecod/wav/: wavplay.c
  group MJPEG
    ./MJPEG/: avi.c mjpeg.c
    ./MJPEG/JPEG/: jaricom.c jcomapi.c jutils.c jerror.c jmemmgr.c jdapimin.c jdapistd.c jdarith.c jdmaster.c jdinput.c jdmarker.c jdhuff.c jdmainct.c jdcoefct.c jdpostct.c jddctmgr.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jquant1.c jquant2.c jdmerge.c jmemnobs.c wrppm.c jidctint.c
  group LwIP_app
    ./LwIP/lwip_app/lwip_comm/: lwip_comm.c
    ./LwIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LwIP_netif
    ./LwIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LwIP_core
    ./LwIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./LwIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP_arch
    ./LwIP/arch/: sys_arch.c
  group LwIP_api
    ./LwIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group USB_otg
    ./USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_device
    ./USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_app
    ./USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group GUI
    ./GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group GUI_APP
    ./GUI_APP/: common.c led_app.c rtc_app.c calculator_app.c gyroscope_app.c picture_app.c ebook_app.c notepad_app.c paint_app.c com_app.c phone_app.c qrcode_app.c wireless_app.c music_app.c usb_app.c eth_app.c camera_app.c
